# Use usb boot
CMDLINE_ROOT_PARTITION = "/dev/sda2"
