## conf/distro/gaea.conf
```bitbake
DISTRO = "gaea"
DISTRO_NAME = "Gaea Linux Project Distro"
DISTRO_VERSION = "1.0"
```
