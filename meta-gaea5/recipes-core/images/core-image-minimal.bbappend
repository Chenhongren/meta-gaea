
IMAGE_INSTALL:append = " \
    gaea-i2c-tool\
"
